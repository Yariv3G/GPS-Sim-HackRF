options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: GPS generator
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: Baseband Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '20'
  states: {}
- name: freq
  id: variable
  parameters:
    value: ' 1575420000'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '20'
  states: {}
- name: input_index
  id: variable_qtgui_chooser
  parameters:
    label: Location (Lat/Lon)
    labels: '[''Berlin'',''HK'',''London'',''Johannesbourgh'', ''NY'', ''circle'']'
    num_opts: '0'
    options: '[0, 1, 2,3,4,5]'
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.6e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: G:\My Drive\Pie & HackRf\GNSS\gps-sdr-sim\HongKong_300s.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: G:\My Drive\Pie & HackRf\GNSS\gps-sdr-sim\Johannesburg_300s.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: G:\My Drive\Pie & HackRf\GNSS\gps-sdr-sim\Berlin_300s.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    file: G:\My Drive\Pie & HackRf\GNSS\gps-sdr-sim\gpssim.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: G:\My Drive\Pie & HackRf\GNSS\gps-sdr-sim\London_300s.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_2_0
  id: blocks_file_source
  parameters:
    file: G:\My Drive\Pie & HackRf\GNSS\gps-sdr-sim\NY_300s.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: input_index
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: BAND1
    args: '"hackrf=681861dc343d1857"'
    bb_gain0: bb_gain
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_selector_0, '1']
- [blocks_file_source_0_0, '0', blocks_selector_0, '3']
- [blocks_file_source_0_1, '0', blocks_selector_0, '0']
- [blocks_file_source_0_1_0, '0', blocks_selector_0, '5']
- [blocks_file_source_0_2, '0', blocks_selector_0, '2']
- [blocks_file_source_0_2_0, '0', blocks_selector_0, '4']
- [blocks_interleaved_char_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
